# Keil uVision project uvproj_5.37.uvprojx, settings and files
target  (ARM-ADS)
  device: ??device?? STMicroelectronics
  output: +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  group 
    ./: 
software components: CMSIS:CORE 4.3.0
